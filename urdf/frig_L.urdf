Commit message: spawner

File: urdf/frig_L.urdf (robot description, URDF)
Before this commit: robot conveyor_belt, 2 links, 1 joints
Links:
- removed link world
- link base_link: geometry collision box size=0.472 0.450 0.492; visual box size=0.472 0.450 0.492
Joints:
- removed joint joint_fix
